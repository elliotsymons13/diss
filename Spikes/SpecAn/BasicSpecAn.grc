options:
  parameters:
    generate_options: qt_gui
    id: basicSpecAn
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Bandwidth
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: CentreFreq
  id: variable
  parameters:
    value: '433000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: CentreFreq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: Bandwidth
    fc: CentreFreq
    fftsize: '1024'
    name: '"Instantaneous Frequency"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: Bandwidth
    fc: CentreFreq
    fftsize: '1024'
    name: '"Waterfall"'
    type: complex
  states: {}

connections:
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
